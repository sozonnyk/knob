## boards/shields/knob/Kconfig.defconfig
```kconfig
if SHIELD_KNOB

config ZMK_KEYBOARD_NAME
    default "Knob"

config BT_CTLR
    default BT

endif
```
